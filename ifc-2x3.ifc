Properties of the parts of a building model (IFC2X3)

# File
Description: Kapillar-Thermostat, Wandmontage, -35…+30 °C, Hysterese einstellbar 2…20 K, Inneneinstellung, Kapillarlänge 1,8 m, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: JA040200, Kapillar-Thermostat, Wandmontage, -35…+30 °C, Hysterese einstellbar 2…20 K, Inneneinstellung, Kapillarlänge 1,8 m
In: Raum
Description: Überwachung oder Regelung von Temperaturen nicht aggressiver, flüssiger und gasförmiger Medien. Besonders geeignet für Wandmontage. Bei Temperaturregelung nicht aggressiver Gase im Kanal ist die Schutzwendel SW-200–12, bei Temperaturregelung in nicht aggressiven Fluiden ist die Tauchhülse TH, in aggressiven Fluiden die Tauchhülse NTH zu verwenden. Tauchhülsen oder Schutzwendel gehören nicht zum Lieferumfang.; Classification: EC002616 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: JA040200; ModelLabel: JET-110 XF; GlobalTradeItemNumber: 4050528046765; ProductURL: https://alre.de/produkt_JA040200
Pset_Specification - NominalLength: 0.144 m; NominalWidth: 0.071 m; NominalDepth: 0.0675 m; NetWeight: 0.363
Pset_ALRE_ETIM_Properties - Max. Betriebstemperatur: 55; Ausführung des Sensors: Kapillarrohr; Ausführung des elektrischen Anschlusses: Schraubanschluss; Explosionsgeschützt: no; Schutzart (IP): IP65; Elektronische Ausführung: no; Geeignet als Wächter: yes; Mediumtemperatur: -35; Anzahl der Kontakte als Wechsler: 1; ETIM-Klasse: EC002616; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-JA040200.pdf
